## components/system/Kconfig
```kconfig
menu "System"

source "$RTT_DIR/components/system/LittlevGL2RTT/Kconfig"

endmenu
```
